# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCLANG5)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: GLCD.c GLCD.h AsciiLib.c
  group TP
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group button_EXINT
    ./button_EXINT/: IRQ_button.c lib_button.c
  group joystick
    ./joystick/: funct_joystick.c lib_joystick.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c
  group Functions
    ./: Wall_moves.h Wall_moves.c Moves.h Moves.c Game_mode.h Game_mode.c
  group CAN
    ./CAN/: CAN.h IRQ_CAN.c lib_CAN.c
software components: CMSIS:CORE 5.4.0
